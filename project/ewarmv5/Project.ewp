# IAR project Project.ewp, settings and files
configuration STM3210E debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\project\ff11\src; ..\..\project\VS10XX
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../Libraries/cmsis/core/CM3/: core_cm3.c system_stm32f10x.c
    ../../Libraries/cmsis/core/CM3/startup/iar/: startup_stm32f10x_hd.s
  group SDCard
    ../: sdcard.c
  group SDCard/FF11
    ../ff11/src/: diskio.c ff.c
  group StdPeriph_Driver
    ../../libraries/stm32f10x_stdperiph_driver/src/: misc.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group User
    ../: lcd.c main.c stm3210e_eval.h stm32_eval.c stm32f10x_it.c usart_printf.h
  group VS10XX
    ../VS10XX/: delay.c spi.c VS10XX.c
